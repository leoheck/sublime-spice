v1 node+ node- sin = 10
v1 node+ node- DC 10
v1 node+ node- DC = 10
v1 node+ node- DC= 10
v1 node+ node- dc= 10
v1 node+ node- dc= (10)
v1 node+ node- pulse = (10)
v1 node+ node- pwl = (10)
   node-

1, 2,3 ,4,4,4,4

dclala dc asaslasldc dcllalaal dc= v= valor lav
dclala dc asaslasldc dcllalaal DC= V= valor lav

.ic v(wew)=sdsd
.ic v(wew) =
.ic     sdsd v(wew)=
.ic V(asas) = 12
	ic V(asas) = 12
	.IC V(kskdskd) = as

xcut
xdut
xnand
XNAND $ teste do comentario

asasas
basasas
xasas
caasas
dasasas

* RESISTORS
*========================================================

* General form:
RXXXXXXX N1 N2 VALUE

* Examples:
R1 1 2 100 dclalala
RC1 12 17 1K

* Semiconductor Resistors, general form:
RXXXXXXX N1 N2 <VALUE> <MNAME> <L=LENGTH> <W=WIDTH> <TEMP=T>

* Examples:
RLOAD 2 10 10K
RMOD 3 7 RMODEL L=10u W=1u>

vname node+ node- y

vlaslkas node+ node- function

lalala ; inline comment
// comment

vname node+ node- function
vname node+ node- function ; this is an inline comment
vname node+ node- function
vteste teste node- function
vname node+ node- function
vname node+ node- function
vname node+ node- function

iname iname vnaime namei namev
vname iname vnaime namei namev  ( asas )

* CAPACITORS
*========================================================

* General form:
CXXXXXXX N+ N- VALUE <IC=INCOND>

* Examples:
CBYP 13 0 1UF
COSC 17 23 10U IC=3V

* Semiconductor Capacitors, general form:
CXXXXXXX N1 N2 <VALUE> <MNAME> <L=LENGTH> <W=WIDTH> <IC=VAL>

Examples:
CLOAD 2 10 10P
CMOD 3 7 CMODEL L=10u W=1u
